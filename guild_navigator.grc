options:
  parameters:
    author: muaddib
    description: remote visualizatino for space folder application
    generate_options: qt_gui
    id: guild_navigator
    output_language: python
  states: {}

blocks:
- name: avg
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,4,1,2
    label: AVERAGE/RAW
    label0: RAW
    label1: AVERAGED
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: fft_length
  id: variable
  parameters:
    value: 256 * int(pow(2, np.ceil(np.log(samp_ratio)/np.log(2))))
  states: {}
- name: rf_bw_gui
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,2,1,2
    label: RF BANDWIDTH
    label0: 1Msps
    label1: 1.92Msps
    label2: 5Msps
    label3: 10Msps
    label4: 20Msps
    num_opts: '5'
    option0: 1e6
    option1: 1.92e6
    option2: 5e6
    option3: 10e6
    option4: 20e6
    type: real
    value: rf_bw
  states: {state: disabled}
- name: rf_bw_gui
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,2,1,2
    label: RF BANDWIDTH
    labels: '[''1.02MHz'', ''1.54MHz'', ''1.79MHz'', ''1.92MHz'', ''2.05MHz'', ''2.16MHz'', ''2.56MHz'', ''2.88MHz'', ''3.2MHz'', ''5.0MHz'', ''10.0MHz'', ''15.0MHz'',''20MHz'', ''25.0MHz'', ''30.0MHz'', ''35.0MHz'', ''40.0MHz'', ''45.0MHz'', ''50.0MHz'', ''55.0MHz'']'
    num_opts: '0'
    options: '[1024000.0, 1536000.0, 1792000.0, 1920000.0, 2048000.0, 2160000.0, 2560000.0, 2880000.0, 3200000.0, 5000000.0, 10000000.0, 15000000.0,20000000.0, 25000000.0, 30000000.0, 35000000.0, 40000000.0, 45000000.0, 50000000.0, 55000000.0]'
    type: real
    value: rf_bw
  states: {}
- name: rf_freq_gui
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: RF FREQ
    start: 64e6
    step: 100e3
    stop: 6e9
    value: 750e6
  states: {}
- name: rf_gain_gui
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: RF GAIN
    start: '0'
    step: '1'
    stop: '80'
    value: '50'
  states: {}
- name: samp_rate_gui
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,2,1,2
    label: SAMPLE RATE
    label0: 1Msps
    label1: 5Msps
    label2: 5Msps
    label3: 20Msps
    label4: 40Msps
    num_opts: '5'
    option0: 1e6
    option1: 5e6
    option2: 10e6
    option3: 20e6
    option4: 40e6
    type: real
    value: samp_rate
  states: {state: disabled}
- name: samp_rate_gui
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    start: 200e3
    step: 500e3
    stop: 56e6
    value: samp_rate
  states: {state: disabled}
- name: samp_rate_gui
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,2,1,2
    label: SAMPLE RATE
    labels: '[''1.02MHz'', ''1.54MHz'', ''1.79MHz'', ''1.92MHz'', ''2.05MHz'', ''2.16MHz'', ''2.56MHz'', ''2.88MHz'', ''3.2MHz'', ''5.0MHz'', ''10.0MHz'', ''15.0MHz'',''20MHz'', ''25.0MHz'', ''30.0MHz'', ''35.0MHz'', ''40.0MHz'', ''45.0MHz'', ''50.0MHz'', ''55.0MHz'']'
    num_opts: '0'
    options: '[1024000.0, 1536000.0, 1792000.0, 1920000.0, 2048000.0, 2160000.0, 2560000.0, 2880000.0, 3200000.0, 5000000.0, 10000000.0, 15000000.0,20000000.0, 25000000.0, 30000000.0, 35000000.0, 40000000.0, 45000000.0, 50000000.0, 55000000.0]'
    type: real
    value: samp_rate
  states: {}
- name: samp_ratio
  id: variable
  parameters:
    value: samp_rate/1E6
  states: {}
- name: vec_per_sec
  id: variable
  parameters:
    value: '4'
  states: {}
- name: vps
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,4,1,2
    label: VECTORS PER SECOND
    label0: '1'
    label1: '2'
    label2: '4'
    label3: '8'
    label4: '16'
    num_opts: '5'
    option0: '1'
    option1: '2'
    option2: '4'
    option3: '8'
    option4: '16'
    type: int
    value: '1'
  states: {}
- name: control_ip
  id: parameter
  parameters:
    label: XMLRPC SERVER IP
    short_id: x
    type: str
    value: 127.0.0.1
  states: {}
- name: control_port
  id: parameter
  parameters:
    label: XMLRPC SERVER PORT
    short_id: X
    type: intx
    value: '8002'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    color1: '"cyan"'
    gui_hint: 2,0,5,6
    ref_level: '100'
    showports: 'True'
    vlen: fft_length
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: rf_bw
  id: parameter
  parameters:
    label: RF BANDWITDH
    short_id: b
    type: eng_float
    value: 10e6
  states: {}
- name: rf_freq
  id: parameter
  parameters:
    label: RF FREQUENCY
    short_id: f
    type: eng_float
    value: 750e6
  states: {}
- name: rf_gain
  id: parameter
  parameters:
    label: RF GAIN
    short_id: g
    type: eng_float
    value: '20.0'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: SAMPLE RATE
    short_id: s
    type: eng_float
    value: 20e6
  states: {}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: 127.0.0.1
    callback: set_rf_gain
    port: '8000'
    variable: rf_gain_gui
  states: {}
- name: xmlrpc_client_0_0
  id: xmlrpc_client
  parameters:
    addr: 127.0.0.1
    callback: set_rf_freq
    port: '8000'
    variable: rf_freq_gui
  states: {}
- name: xmlrpc_client_0_0_0
  id: xmlrpc_client
  parameters:
    addr: 127.0.0.1
    callback: set_rf_bw
    port: '8000'
    variable: rf_bw_gui
  states: {}
- name: xmlrpc_client_0_0_0_0
  id: xmlrpc_client
  parameters:
    addr: 127.0.0.1
    callback: set_samp_rate
    port: '8000'
    variable: samp_rate_gui
  states: {}
- name: xmlrpc_client_0_0_0_0_0
  id: xmlrpc_client
  parameters:
    addr: 127.0.0.1
    callback: set_samp_rate
    port: '8001'
    variable: samp_rate_gui
  states: {}
- name: xmlrpc_client_0_0_0_0_0_0
  id: xmlrpc_client
  parameters:
    addr: 127.0.0.1
    callback: set_vec_per_sec
    port: '8001'
    variable: vps
  states: {}
- name: xmlrpc_client_0_0_0_0_0_0_0
  id: xmlrpc_client
  parameters:
    addr: 127.0.0.1
    callback: set_avg_on_off
    port: '8001'
    variable: avg
  states: {}
- name: xmlrpc_serv_ip
  id: xmlrpc_server
  parameters:
    addr: 127.0.0.1
    port: control_port
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://"+str(zmq_in_ip)+":"+str(zmq_in_port)'
    pass_tags: 'True'
    timeout: '100'
    type: float
    vlen: fft_length
  states: {}
- name: zmq_in_ip
  id: parameter
  parameters:
    label: ZMQ IN IP ADDR
    short_id: z
    type: str
    value: 127.0.0.1
  states: {}
- name: zmq_in_port
  id: parameter
  parameters:
    label: ZMQ IN IP PORT
    short_id: Z
    value: '5001'
  states: {}

connections:
- [zeromq_sub_source_0, '0', qtgui_vector_sink_f_0, '0']

metadata:
  file_format: 1
