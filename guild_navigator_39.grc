options:
  parameters:
    author: muaddib
    description: remote visualizatino for space folder application
    generate_options: qt_gui
    id: guild_navigator39
    output_language: python
  states: {}

blocks:
- name: avg
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,4,1,2
    label: AVERAGE/RAW
    label0: AVERAGE
    label1: RAW
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: fft_length
  id: variable
  parameters:
    value: 256 * int(pow(2, np.ceil(np.log(samp_ratio)/np.log(2))))
  states: {}
- name: rf_bw_gui
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,2,1,2
    label: RF BANDWIDTH
    label0: 1Msps
    label1: 1.92Msps
    label2: 5Msps
    label3: 10Msps
    label4: 20Msps
    num_opts: '5'
    option0: 1e6
    option1: 1.92e6
    option2: 5e6
    option3: 10e6
    option4: 20e6
    type: real
    value: rf_bw
  states: {}
- name: rf_freq_gui
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: RF FREQ
    start: 64e6
    step: 100e3
    stop: 6e9
    value: 750e6
  states: {}
- name: rf_gain_gui
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: RF GAIN
    start: '0'
    step: '1'
    stop: '80'
    value: '50'
  states: {}
- name: samp_rate_gui
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,2,1,2
    label: SAMPLE RATE
    label0: 1Msps
    label1: 5Msps
    label2: 5Msps
    label3: 20Msps
    label4: 40Msps
    num_opts: '5'
    option0: 1e6
    option1: 5e6
    option2: 10e6
    option3: 20e6
    option4: 40e6
    type: real
    value: samp_rate
  states: {}
- name: samp_ratio
  id: variable
  parameters:
    value: samp_rate/1E6
  states: {}
- name: vec_per_sec
  id: variable
  parameters:
    value: '4'
  states: {}
- name: vps
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,4,1,2
    label: VECTORS PER SECOND
    label0: '1'
    label1: '2'
    label2: '4'
    label3: '8'
    label4: '16'
    num_opts: '5'
    option0: '1'
    option1: '2'
    option2: '4'
    option3: '8'
    option4: '16'
    type: int
    value: '1'
  states: {}
- name: control_ip
  id: parameter
  parameters:
    label: XMLRPC SERVER IP
    short_id: x
    type: str
    value: 127.0.0.1
  states: {}
- name: control_port
  id: parameter
  parameters:
    label: XMLRPC SERVER PORT
    short_id: X
    type: intx
    value: '8002'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    color1: '"cyan"'
    gui_hint: 2,0,5,6
    ref_level: '100'
    showports: 'True'
    vlen: fft_length
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: rf_bw
  id: parameter
  parameters:
    label: RF BANDWITDH
    short_id: b
    type: eng_float
    value: 10e6
  states: {}
- name: rf_freq
  id: parameter
  parameters:
    label: RF FREQUENCY
    short_id: f
    type: eng_float
    value: 750e6
  states: {}
- name: rf_gain
  id: parameter
  parameters:
    label: RF GAIN
    short_id: g
    type: eng_float
    value: '50.0'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: SAMPLE RATE
    short_id: s
    type: eng_float
    value: 10e6
  states: {}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: 127.0.0.1
    callback: set_rf_gain
    port: '8000'
    variable: rf_gain_gui
  states: {}
- name: xmlrpc_client_0_0
  id: xmlrpc_client
  parameters:
    addr: 127.0.0.1
    callback: set_rf_freq
    port: '8000'
    variable: rf_freq_gui
  states: {}
- name: xmlrpc_client_0_0_0
  id: xmlrpc_client
  parameters:
    addr: 127.0.0.1
    callback: set_rf_bw
    port: '8000'
    variable: rf_bw_gui
  states: {}
- name: xmlrpc_client_0_0_0_0
  id: xmlrpc_client
  parameters:
    addr: 127.0.0.1
    callback: set_samp_rate
    port: '8000'
    variable: samp_rate_gui
  states: {}
- name: xmlrpc_client_0_0_0_0_0
  id: xmlrpc_client
  parameters:
    addr: 127.0.0.1
    callback: set_samp_rate
    port: '8001'
    variable: samp_rate_gui
  states: {}
- name: xmlrpc_client_0_0_0_0_0_0
  id: xmlrpc_client
  parameters:
    addr: 127.0.0.1
    callback: set_vec_per_sec
    port: '8001'
    variable: vps
  states: {}
- name: xmlrpc_client_0_0_0_0_0_0_0
  id: xmlrpc_client
  parameters:
    addr: 127.0.0.1
    callback: set_avg
    port: '8001'
    variable: avg
  states: {}
- name: xmlrpc_serv_ip
  id: xmlrpc_server
  parameters:
    addr: 127.0.0.1
    port: control_port
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://"+str(zmq_in_ip)+":"+str(zmq_in_port)'
    pass_tags: 'True'
    timeout: '100'
    type: float
    vlen: fft_length
  states: {}
- name: zmq_in_ip
  id: parameter
  parameters:
    label: ZMQ IN IP ADDR
    short_id: z
    type: str
    value: 127.0.0.1
  states: {}
- name: zmq_in_port
  id: parameter
  parameters:
    label: ZMQ IN IP PORT
    short_id: Z
    value: '5001'
  states: {}

connections:
- [zeromq_sub_source_0, '0', qtgui_vector_sink_f_0, '0']

metadata:
  file_format: 1
