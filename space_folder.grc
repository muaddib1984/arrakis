options:
  parameters:
    author: muaddib
    category: Custom
    description: remote ingest and decimation for low bw link
    generate_options: no_gui
    id: space_folder
    output_language: python
    run_options: run
  states: {}

blocks:
- name: avg_on_off
  id: variable
  parameters:
    value: '0'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: 256 * int(pow(2, np.ceil(np.log(samp_ratio)/np.log(2))))
  states: {}
- name: samp_ratio
  id: variable
  parameters:
    value: samp_rate/1E6
  states: {}
- name: vec_per_sec
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Compute power
    vlen: fft_len
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    comment: Video average down to 10 FFT/sec
    decim: '1'
    type: float
    vlen: fft_len
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    comment: |-
      Using the sample rate and fft length 
      we can put in a # of vectors per second as an input.
      This is a way to limit the output data rate needed to 
      plot spectrum on the remote control side.
    n: int(round(samp_rate/fft_len/vec_per_sec))
    type: complex
    vlen: fft_len
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1'
    max_iter: '16'
    scale: '1'
    type: float
    vlen: fft_len
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '16'
    max_iter: '4000'
    scale: 1/16
    type: float
    vlen: fft_len
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: 10*np.log10(1.0/fft_len)
    n: '10'
    vlen: fft_len
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: avg_on_off
    type: float
    vlen: fft_len
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: avg_on_off
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
    vlen: fft_len
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: control_ip
  id: parameter
  parameters:
    label: XMLRPC SERVER IP
    short_id: x
    type: str
    value: 127.0.0.1
  states: {}
- name: control_port
  id: parameter
  parameters:
    label: XMLRPC SERVER PORT
    short_id: X
    type: intx
    value: '8001'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_len)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: SAMPLE RATE
    short_id: s
    type: eng_float
    value: 20e6
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: mag_sqrd
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: mag_sqrd
  states: {}
- name: xmlrpc_serv_ip
  id: xmlrpc_server
  parameters:
    addr: 127.0.0.1
    port: control_port
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: '"tcp://"+str(zmq_out_ip)+":"+str(zmq_out_port)'
    pass_tags: 'True'
    timeout: '100'
    type: float
    vlen: fft_len
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://"+str(zmq_in_ip)+":"+str(zmq_in_port)'
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zmq_in_ip
  id: parameter
  parameters:
    label: ZMQ IN IP ADDR
    short_id: z
    type: str
    value: 127.0.0.1
  states: {}
- name: zmq_in_port
  id: parameter
  parameters:
    label: ZMQ IN IP PORT
    short_id: Z
    value: '5000'
  states: {}
- name: zmq_out_ip
  id: parameter
  parameters:
    label: ZMQ OUT IP ADDR
    short_id: o
    type: str
    value: '"127.0.0.1"'
  states: {}
- name: zmq_out_port
  id: parameter
  parameters:
    label: ZMQ OUT IP PORT
    short_id: O
    type: str
    value: '5001'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', virtual_sink_0, '0']
- [blocks_integrate_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_keep_one_in_n_0, '0', fft_vxx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_selector_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_selector_0_0, '1']
- [blocks_nlog10_ff_0, '0', zeromq_pub_sink_0, '0']
- [blocks_selector_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_selector_0, '1', blocks_moving_average_xx_0_0, '0']
- [blocks_selector_0_0, '0', blocks_integrate_xx_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_keep_one_in_n_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0, '0', blocks_selector_0, '0']
- [zeromq_sub_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
